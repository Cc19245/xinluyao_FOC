# Keil uVision project DEMO.uvprojx, settings and files
target FLASH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MOTOR
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Library\CMSIS;..\Library\STM32F10x_FWLib\inc;..\System\delay;..\System\sys;..\System\usart;..\User;..\BSP\LED;..\BSP\LCD;..\User\USB\CONFIG;..\User\USB\STM32_USB-FS-Device_Driver\inc;..\BSP\PWM;..\BSP\ENCODER;..\BSP\TIMER;..\BSP\24CXX;..\BSP\MOS;..\BSP\ADC;..\Module\FOC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Library/CMSIS/: core_cm3.c startup_stm32f10x_hd.s
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
  group SPL
    ../Library/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/PWM/: bsp_pwm.c
    ../BSP/LED/: bsp_led.c
    ../BSP/KEY/: bsp_key.c
    ../BSP/ENCODER/: bsp_encoder.c
    ../BSP/TIMER/: bsp_timer2.c
    ../BSP/24CXX/: bsp_24cxx.c bsp_myiic.c
    ../BSP/MOS/: bsp_mos.c
    ../BSP/ADC/: bsp_adc.c
  group FOC
    ../Module/FOC/: circle_limitation.c lpf.c mc_angle.c mc_ctrl.c mc_flag.c mc_foc.c mc_math.c mc_pid.c mc_svpwm.c
